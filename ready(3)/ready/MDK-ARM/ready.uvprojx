# Keil uVision project ready.uvprojx, settings and files
target ready (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F750V8Tx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.15.1
  cpu: IRAM(0x20000000-0x2004FFFF) IROM(0x8000000-0x800FFFF) CLOCK(12000000) FPU3(SFPU) CPUTYPE("Cortex-M7") ELITTLE TZ
  output: ready +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F750xx
  c include: ../Core/Inc;../Drivers/STM32F7xx_HAL_Driver/Inc;../Drivers/STM32F7xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F7xx/Include;../Drivers/CMSIS/Include;../application;../Math;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM7/r0p1;../module;../Motor;../task;../USMAT
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x50000
  group Application/MDK-ARM
    ./: startup_stm32f750xx.s
  group Application/User/Core
    ../Core/Src/: freertos.c main.c gpio.c adc.c dma.c tim.c usart.c stm32f7xx_it.c stm32f7xx_hal_msp.c stm32f7xx_hal_timebase_tim.c
  group Drivers/STM32F7xx_HAL_Driver
    ../Drivers/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal_adc.c stm32f7xx_hal_adc_ex.c stm32f7xx_hal_rcc.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_flash.c stm32f7xx_hal_flash_ex.c stm32f7xx_hal_gpio.c stm32f7xx_hal_dma.c stm32f7xx_hal_dma_ex.c stm32f7xx_hal_pwr.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_cortex.c stm32f7xx_hal.c stm32f7xx_hal_i2c.c stm32f7xx_hal_i2c_ex.c stm32f7xx_hal_exti.c stm32f7xx_hal_tim.c stm32f7xx_hal_tim_ex.c stm32f7xx_hal_uart.c stm32f7xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f7xx.c
  group MIddlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM7/r0p1/: port.c
  group Motor
    ../Motor/: Encoder.c Encoder.h motor.c motor.h motor_task.c motor_task.h
  group task
    ../task/: IIC.c IIC.h main_task.c main_task.h Rudder_control.c Rudder_control.h task_create.c task_create.h temporary_task.c temporary_task.h delay.c delay.h
  group module
    ../module/: bsp_buzzer.c bsp_buzzer.h bsp_led.c bsp_led.h bsp_linefollower.c bsp_linefollower.h follow_line.c follow_line.h imu_task.c imu_task.h openmv.c openmv.h QR.c QR.h
  group math
    ../Math/: pid.c pid.h sin_generate.c sin_generate.h
  group usmart
    ../USMAT/: sys.c sys.h uart.c uart.h usmart.c usmart.h usmart_config.c usmart_str.c usmart_str.h
  group application
    ../application/: barrier.c barrier.h ican_test.c ican_test.h map.h map.c map_message.c map_message.h motion.c motion.h scaner.c scaner.h speed_ctrl.c speed_ctrl.h sys.h turn.c turn.h
software components: CMSIS:CORE 4.3.0
